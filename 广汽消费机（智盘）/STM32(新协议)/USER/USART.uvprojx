# Keil uVision project USART.uvprojx, settings and files
target USART (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: D:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin -o  ../OBJ/USART.bin  ../OBJ/USART.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\RELAY;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\wg;..\HARDWARE\WDG;..\HARDWARE\SST225VF;..\HARDWARE\EC20;..\HARDWARE\Optocoupler;..\HARDWARE\RS485;..\HARDWARE\Volume;..\HARDWARE\STMFLASH;..\RC522;..\OLED;..\DS1302;..\Sysvar;..\SYSFUN;..\GUI;..\HARDWARE\24CXX_2;..\HARDWARE\IIC_2;..\W5500;..\4.3inchLCD;..\LCD_Driver;..\CRC;..\IAP
  memory RVCT4: ROM 0x8006000 size 0x1a000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c GPIO-ALS.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c SYSREST.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/RELAY/: Relay.c
    ../HARDWARE/W25QXX/: W25QXX.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/Optocoupler/: Optocoupler.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/wg/: wg1.c wg2.c
    ../HARDWARE/24CXX_2/: 24cxx_2.c
    ../HARDWARE/IIC_2/: myiic_2.c
    ../HARDWARE/EC20/: EC20.c
    ../HARDWARE/Volume/: Volume.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group RC522
    ../RC522/: rc522_config.c rc522_function.c
  group DS1302
    ../DS1302/: ds1302.c
  group Sysvar
    ../Sysvar/: Sysvar.c
  group SYSFUN
    ../SYSFUN/: keyfun.c AT24C256.c syscomm.c COMCMD.c Name.c CardProcess.c Pass.c Default.c Record.c Mach.c WIFI.c Cardrw.c BlackName.c Interval.c EC20fun.c QR_code.c speak.c Heartbeat.c LCD12864.c LCD12864_Config.c Upload.c tm1650.c Wisdom_plate.c Consum_Config.c IAP_UpData.c
  group GUI
    ../GUI/: menu.c MenuFun.c
  group W5500
    ../W5500/: W5500.c W5500_Config.c RJ45CMD.c
  group LCD_Driver
    ../LCD_Driver/: LCD_Dis.c LCD_Config.c
  group TXT
    ../: REDME.txt
  group CRC
    ../CRC/: crc.c
  group IAP
    ../IAP/: iap.c
